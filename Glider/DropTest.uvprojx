# Keil uVision project DropTest.uvprojx, settings and files
target DropTest (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.pdsc
  cpu: CPUTYPE("Cortex-M3")
  output: DropTest
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DDEVICE_SEMIHOST=1 -D__ASSERT_MSG -DTARGET_LPC1768 -DTARGET_RELEASE --no_rtti -DMBED_BUILD_TIMESTAMP=1492746888.52 -D__CORTEX_M3 -DDEVICE_DEBUG_AWARENESS=1 -DTARGET_M3 -c -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DARM_MATH_CM3 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTINOUT=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M3 -DDEVICE_ETHERNET=1 -DTARGET_LPCTarget -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL_FC=1 -DDEVICE_LOCALFILESYSTEM=1 -DDEVICE_SERIAL=1 -DTARGET_LPC176X -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTARGET_NXP -DTARGET_MBED_LPC1768 -D__MBED_CMSIS_RTOS_CM
  c include: .; mbed-os; BMP180; HMC5883L; Glider; mbed-os/mbed-os/.; mbed-os/mbed-os/docs; mbed-os/mbed-os/features; mbed-os/mbed-os/features/frameworks; mbed-os/mbed-os/features/frameworks/greentea-client; mbed-os/mbed-os/features/frameworks/greentea-client/greentea-client; mbed-os/mbed-os/features/frameworks/greentea-client/source; mbed-os/mbed-os/features/frameworks/unity; mbed-os/mbed-os/features/frameworks/unity/source; mbed-os/mbed-os/features/frameworks/unity/unity; mbed-os/mbed-os/features/frameworks/utest; mbed-os/mbed-os/features/frameworks/utest/source; mbed-os/mbed-os/features/frameworks/utest/utest; mbed-os/mbed-os/features/mbedtls; mbed-os/mbed-os/features/mbedtls/importer; mbed-os/mbed-os/features/mbedtls/inc; mbed-os/mbed-os/features/mbedtls/inc/mbedtls; mbed-os/mbed-os/features/mbedtls/src; mbed-os/mbed-os/features/net; mbed-os/mbed-os/features/net/network-socket; mbed-os/mbed-os/features/storage; mbed-os/mbed-os/hal; mbed-os/mbed-os/hal/api; mbed-os/mbed-os/hal/common; mbed-os/mbed-os/hal/hal; mbed-os/mbed-os/hal/hal/storage_abstraction; mbed-os/mbed-os/hal/targets; mbed-os/mbed-os/hal/targets/cmsis; mbed-os/mbed-os/hal/targets/cmsis/TARGET_NXP; mbed-os/mbed-os/hal/targets/cmsis/TARGET_NXP/TARGET_LPC176X; mbed-os/mbed-os/hal/targets/cmsis/TARGET_NXP/TARGET_LPC176X/TOOLCHAIN_ARM_STD; mbed-os/mbed-os/hal/targets/hal; mbed-os/mbed-os/hal/targets/hal/TARGET_NXP; mbed-os/mbed-os/hal/targets/hal/TARGET_NXP/TARGET_LPC176X; mbed-os/mbed-os/hal/targets/hal/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768; mbed-os/mbed-os/rtos; mbed-os/mbed-os/rtos/rtos; mbed-os/mbed-os/rtos/rtx; mbed-os/mbed-os/rtos/rtx/TARGET_CORTEX_M; mbed-os/mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_M3; mbed-os/mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed-os/mbed-os/hal/targets/cmsis/TARGET_NXP/TARGET_LPC176X/TOOLCHAIN_ARM_STD/LPC1768.sct
  group BMP180
    BMP180/: BMP180.cpp BMP180.h
  group DropTest
    ./: main.cpp mbed_config.h
  group Glider
    Glider/: Glider.cpp Glider.h
  group HMC5883L
    HMC5883L/: HMC5883L.cpp HMC5883L.h
  group mbed-os
    mbed-os/mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    mbed-os/mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
    mbed-os/mbed-os/hal/common/: AnalogIn.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp mbed_alloc_wrappers.cpp mbed_assert.c mbed_board.c mbed_critical.c mbed_error.c mbed_gpio.c mbed_interface.c mbed_lp_ticker_api.c mbed_mem_trace.c mbed_pinmap_common.c mbed_rtc_time.cpp mbed_semihost_api.c mbed_ticker_api.c mbed_us_ticker_api.c mbed_wait_api.c RawSerial.cpp retarget.cpp Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp
    mbed-os/mbed-os/hal/api/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h Callback.h CallChain.h CAN.h can_helper.h CircularBuffer.h critical.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h platform.h PlatformMutex.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h rtc_time.h semihost_api.h Serial.h SerialBase.h SingletonPtr.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h wait_api.h
    mbed-os/mbed-os/hal/targets/hal/TARGET_NXP/TARGET_LPC176X/: analogin_api.c analogout_api.c can_api.c ethernet_api.c gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c objects.h PeripheralNames.h pinmap.c port_api.c PortNames.h pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
    mbed-os/mbed-os/hal/hal/: analogin_api.h analogout_api.h buffer.h can_api.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h us_ticker_api.h
    mbed-os/mbed-os/hal/targets/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed-os/mbed-os/features/net/network-socket/: CellularInterface.h EthInterface.h MeshInterface.h NetworkInterface.h NetworkStack.cpp NetworkStack.h nsapi.h nsapi_dns.cpp nsapi_dns.h nsapi_types.h Socket.cpp Socket.h SocketAddress.cpp SocketAddress.h TCPServer.cpp TCPServer.h TCPSocket.cpp TCPSocket.h UDPSocket.cpp UDPSocket.h WiFiInterface.h
    mbed-os/mbed-os/hal/targets/cmsis/TARGET_NXP/TARGET_LPC176X/: cmsis.h cmsis_nvic.c cmsis_nvic.h LPC17xx.h system_LPC17xx.c system_LPC17xx.h
    mbed-os/mbed-os/rtos/rtx/TARGET_CORTEX_M/: cmsis_os.h HAL_CM.c rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Memory.c rt_Memory.h rt_Mutex.c rt_Mutex.h rt_OsEventObserver.c rt_OsEventObserver.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_Timer.c rt_Timer.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf_CM.c RTX_Config.h
    mbed-os/mbed-os/hal/targets/hal/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768/: device.h PinNames.h reserved_pins.h
    mbed-os/mbed-os/hal/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    mbed-os/mbed-os/features/frameworks/greentea-client/source/: greentea_serial.cpp test_env.cpp
    mbed-os/mbed-os/features/frameworks/greentea-client/greentea-client/: greentea_serial.h test_env.h
    mbed-os/mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM/: HAL_CM3.c SVC_Table.S
    mbed-os/mbed-os/rtos/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.c rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
    mbed-os/mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
    mbed-os/mbed-os/hal/targets/cmsis/TARGET_NXP/TARGET_LPC176X/TOOLCHAIN_ARM_STD/: startup_LPC17xx.S sys.cpp
    mbed-os/mbed-os/features/frameworks/unity/source/: unity.c
    mbed-os/mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
    mbed-os/mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_stack_trace.cpp utest_types.cpp
    mbed-os/mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
